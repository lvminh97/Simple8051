# Keil uVision project ProductCount.uvproj, settings and files
target Target (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ProductCount +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c
  group Inc
    ./: ds1307.h LCD.h
